# Keil uVision project ZET6-Modbus-demo.uvprojx, settings and files
target ZET6-Modbus-demo (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ZET6-Modbus-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/Middlewares;../Drivers/Middlewares/libmodbus;../Drivers/Module_Drivers;../Drivers/Module_Drivers/SD;../Drivers/Middlewares/Internet;../Drivers/Middlewares/Ethernet;../Drivers/Middlewares/Ethernet/W5500;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c sdio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Driver/Middlewares/libmodbus
    ../Drivers/Middlewares/libmodbus/: errno.c modbus.c modbus-data.c modbus-st-rtu.c
  group Driver/Module_Drivers
    ../Drivers/Module_Drivers/: uart_device.c Conf_SPI_W5500.c My_debug.c
  group Driver/Middlewares/Internet
    ../Drivers/Middlewares/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
  group Driver/Middlewares/Ethernet
    ../Drivers/Middlewares/Ethernet/: socket.c wizchip_conf.c
    ../Drivers/Middlewares/Ethernet/W5500/: w5500.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Module_Drivers/SD
    ../Drivers/Module_Drivers/SD/: myDiskio.c SD.c
software components: CMSIS:CORE 4.3.0
